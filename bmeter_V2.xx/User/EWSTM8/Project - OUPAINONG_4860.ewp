# IAR project Project - OUPAINONG_4860.ewp, settings and files
configuration STM8S208 (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; OUPAINONG_4860; SINGLE_TRIP
  ICCSTM8.CCIncludePath2: ..\..\STM8S_StdPeriph_Driver\inc; ..\..\STM8S_StdPeriph_Driver\src; ..\
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: 9040_P200_Vxxx_4860_SingleTrip.HEX
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group StdPeriph_Drivers
    ../../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_tim1.c stm8s_tim2.c stm8s_uart1.c
  group User
    ../: bike.c bl55072.c display.c display_6040.c display_8794GCT.c display_9040.c main.c pcf8563.c stm8s_it.c yxt.c
