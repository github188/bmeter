<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM8S208</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <group>
    <name>StdPeriph_Drivers</name>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_adc1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_itc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_rst.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\STM8S_StdPeriph_Driver\src\stm8s_uart1.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\bike.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bl55072.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\display.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\display_6040.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\display_8794GCT.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\display_9040.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\display_TM1624.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\display_TM1640.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\pcf8563.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm8s_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\TM16XX.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\yxt.c</name>
    </file>
  </group>
</project>


